PACKAGECONFIG:append = " linuxfb fontconfig"
