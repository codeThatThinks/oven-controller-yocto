IMAGE_INSTALL:append = " oven-controller-gui"
