CMDLINE:append = " fbcon=map:10 fbcon=font:VGA8x8"
